# Keil uVision project AR_SmartChassis_LowerHost_YQ.uvprojx, settings and files
target AR_SmartChassis_LowerHost (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: AR_SmartChassis_LowerHost +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\HARDWARE\LED;..\HARDWARE\REMOTER;..\HARDWARE\ADC;..\HARDWARE\DMS055A;..\HARDWARE\TIMER;..\HARDWARE\KEY;..\HARDWARE\CAN;..\HARDWARE\SONIC;..\HARDWARE\YQ;..\HARDWARE\INDUSTRY;..\HARDWARE\CLIENT;..\HARDWARE\JY01;..\HARDWARE\PID;..\SYSTEM\usart;..\HARDWARE\WDG;..\HARDWARE\DMA
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c system_stm32f10x.c
  group SYSTEM
    ./: stm32f10x_it.c
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/DMS055A/: dms055a.c
    ../HARDWARE/REMOTER/: remoter.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/CAN/: can.c
    ../HARDWARE/YQ/: yq.c
    ../HARDWARE/INDUSTRY/: industry.c
    ../HARDWARE/CLIENT/: client.c
    ../HARDWARE/JY01/: jy01.c
    ../HARDWARE/PID/: pid.c
    ../HARDWARE/SONIC/: sonic.c
    ../HARDWARE/WDG/: wdg.c
    ../HARDWARE/DMA/: dma.c
  group README
    ../: README.TXT
